# Keil uVision project MC02_LCD_Smoke.uvprojx, settings and files
target LCD_SMOKE (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32H723VGTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(24000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: MC02_LCD_Smoke +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32H723xx,USE_HAL_DRIVER,HSE_VALUE=24000000UL,RM_PROFILE=2,HAL_UART_MODULE_ENABLED
  c include: ..\LcdSmoke;..\Config;..\Device;..\APP;..\BSP;..\..\..\..\hard1\hard_lib_1\MC02_data\mc02_control\Core\Inc;..\..\..\..\hard1\hard_lib_1\MC02_data\mc02_control\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\..\..\hard1\hard_lib_1\MC02_data\mc02_control\Drivers\CMSIS\Include;..\..\..\..\hard1\hard_lib_1\MC02_data\mc02_control\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\..\..\hard1\hard_lib_1\MC02_data\mc02_control\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\hard1\hard_lib_1\MC02_data\mc02_control\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  asm include: ..\..\..\..\hard1\hard_lib_1\MC02_data\mc02_control\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  scatter file: ..\BSP\layout.sct
  group LCD smoke test
    ../LcdSmoke/: main.c panel.c
    ../APP/: keys.c
  group MC02 BSP
    ../BSP/: board.c timebase.c
  group MC02 startup
    ../../../../hard1/hard_lib_1/MC02_data/mc02_control/MDK-ARM/: startup_stm32h723xx.s
    ../../../../hard1/hard_lib_1/MC02_data/mc02_control/Core/Src/: system_stm32h7xx.c
  group STM32H7 HAL
    ../../../../hard1/hard_lib_1/MC02_data/mc02_control/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group FreeRTOS kernel and Cortex-M port
    ../../../../hard1/hard_lib_1/MC02_data/mc02_control/Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c
    ../../../../hard1/hard_lib_1/MC02_data/mc02_control/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
