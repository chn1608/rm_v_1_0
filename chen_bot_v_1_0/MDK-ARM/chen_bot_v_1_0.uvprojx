# Keil uVision project chen_bot_v_1_0.uvprojx, settings and files
target CHEN_BOT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(24000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: chen_bot_v_1_0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32H723xx,USE_HAL_DRIVER,HSE_VALUE=24000000UL,CHEN_PROFILE=2,CHEN_FEATURE_ACTUATION=0
  c include: config;..\Firmware\Config;..\Firmware\BSP;..\Firmware\Device;..\Firmware\Device\Real;..\Firmware\Device\Mock;..\Firmware\Control;..\Firmware\Service;..\Firmware\Debug;..\Firmware\APP;..\Firmware\HMI;..\..\hard1\hard_lib_1\MC02_data\mc02_control\Core\Inc;..\..\hard1\hard_lib_1\MC02_data\mc02_control\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\hard1\hard_lib_1\MC02_data\mc02_control\Drivers\CMSIS\Include;..\..\hard1\hard_lib_1\MC02_data\mc02_control\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\hard1\hard_lib_1\MC02_data\mc02_control\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\hard1\hard_lib_1\MC02_data\mc02_control\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  asm include: ..\..\..\..\hard1\hard_lib_1\MC02_data\mc02_control\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  scatter file: ..\Firmware\BSP\layout.sct
  group Application/User/APP
    ../Firmware/: main.c
    ../Firmware/APP/: app.c
  group Application/User/HMI
    ../Firmware/HMI/: hmi.c
  group Application/User/Control
    ../Firmware/Control/: chassis.c pid.c safety.c servo_ctrl.c
  group Application/User/Service
    ../Firmware/Service/: faults.c protocol.c snapshot.c
  group Application/User/Debug
    ../Firmware/Debug/: debug_service.c
  group Application/User/Config
    ../Firmware/Config/: params.c
  group Drivers/BSP
    ../Firmware/BSP/: board.c lcd.c uart_link.c timebase.c can_link.c
  group Drivers/Devices
    ../Firmware/Device/: keys.c
    ../Firmware/Device/Real/: real_devices.c
  group Drivers/Devices/Mock
    ../Firmware/Device/Mock/: mock.c
  group Application/MDK-ARM
    ../../hard1/hard_lib_1/MC02_data/mc02_control/MDK-ARM/: startup_stm32h723xx.s
  group Drivers/CMSIS
    ../../hard1/hard_lib_1/MC02_data/mc02_control/Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../hard1/hard_lib_1/MC02_data/mc02_control/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_fdcan.c
  group Middlewares/FreeRTOS
    ../../hard1/hard_lib_1/MC02_data/mc02_control/Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c list.c
    ../../hard1/hard_lib_1/MC02_data/mc02_control/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
